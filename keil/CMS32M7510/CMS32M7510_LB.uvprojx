# Keil uVision project CMS32M7510_LB.uvprojx, settings and files
target CMS7510 (6210000::V6.21::ARMCLANG)
  device: CMS32M75xxGK64FB Cmsemicon
  pack: Cmsemicon.CMS32M75xx.0.1.1
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x20010000,0x1000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: CMS32M7510 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\code\2_mcu_h;..\..\Libary\CMSIS\Core\Include;..\..\Libary\Device\CMS32M7xxx\Include;..\..\code\head\3_user_h;..\..\code\head\4_powerlib_h;..\..\Libary\Device\CMS32M7xxx\Source;..\..\Libary\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000200 size 0x10000
  scatter file: .\Objects\CMS32M7510.sct
  group Device
    ../../Libary/Device/CMS32M7xxx/Source/: system_BAT32G439.c isr_BAT32G439.c
    ../../Libary/Device/CMS32M7xxx/Source/ARM/: startup_BAT32G439.s
  group 2_mcu_h
    ../../code/2_mcu_h/: base_type.h
  group driver_s
    ../../Libary/StdDriver/src/: dma.c elc.c sci.c
  group driver_h
    ../../Libary/StdDriver/inc/: dma.h elc.h
  group user_s
    ../../code/source/3_user_s/: main.c interrupt.c sys_struct.c user_sample.c user_function.c sys_variable_init.c user_fault_check.c sys_hardware_init.c sys_state_machine.c user_communication.c
  group user_h
    ../../code/head/3_user_h/: sys_struct.h user_sample.h user_function.h sys_mcu_header.h sys_define_config.h sys_define_param.h sys_hardware_init.h sys_state_machine.h user_communication.h
  group powerlib_s
    ../../code/source/4_powerlib_s/: DC_ctrl.c PID_ctrl.c
  group powerlib_h
    ../../code/head/4_powerlib_h/: DC_ctrl.h PID_ctrl.h
  group doc
    ../../: readme.txt
